# Keil uVision project MCUCore.uvproj, settings and files
target MCUCore (MCS-51)
  device: SH79F6441 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0xFFFF) XRAM(0-0xAFF) CLOCK(24000000)
  output: MCUCore +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: .\header
  group User
    ./code/: Main.c Initial.c Interrupt.c AfeProcess.c ShutDown.c Key.c Led.c Uart.c Common.c Memory.c
  group Driver
    ./code/: STARTUP.A51 AfeMtp.c Balance.c Calibrate.c Calculate.c GasGauge.c McuFlash.c ExtE2PRom.c RTC.c TwiIO.c TwiModule.c
  group ISP
    ./code/: ISP.c
  group Header
    ./header/: Main.h Calibrate.h Uart.h Led.h Memory.h c51_type.h GasGauge.h ExtE2PRomRTC.h McuFlash.h AfeMtp.h TwiIO.h TwiModule.h Common.h System.h SH79F6441.h ISP.h Key.h
  group EEPROM
    ./code/: DataFlash.c
target Eeprom (MCS-51)
  device: SH79F1612B Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0-0x2FF) CLOCK(16600000)
  output: Eeprom +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\header
